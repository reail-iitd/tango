Commit message: Updated climb to ladder

File: PyBullet/models/urdf/trolley.urdf (robot description, URDF)
Before this commit: robot apple, 1 links, 0 joints
Links:
- link base_link: mass .1 -> 1.99
