Commit message: Added goal5 cube to box data (partial)

File: PyBullet/models/urdf/cupboard/cupboard.urdf (robot description, URDF)
Before this commit: robot walls, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=models/meshes/cupboard/cupboard.obj scale=10 10 10
