Commit message: Added functionality of dropping object or switching light with stick

File: PyBullet/models/urdf/stick.urdf (robot description, URDF)
Before this commit: robot stick, 1 links, 0 joints
Links:
- link base_link: mass 5 -> 1
