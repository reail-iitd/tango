Commit message: added cleaning video

File: PyBullet/models/urdf/tray.urdf (robot description, URDF)
Before this commit: robot tray.SLDPRT, 1 links, 0 joints
Links:
- link tray.SLDPRT: mass 0.18496 -> 2.18496
