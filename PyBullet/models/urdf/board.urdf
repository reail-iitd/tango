Commit message: Changed dynamics (mass = 0) for board and paper before changing state to stuck

File: PyBullet/models/urdf/board.urdf (robot description, URDF)
Before this commit: robot board.SLDPRT, 1 links, 0 joints
Links:
- link board.SLDPRT: mass 7.8817 -> 1
