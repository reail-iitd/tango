Commit message: Updated tolerances and constraint positions of shelf

File: PyBullet/models/urdf/shelf.urdf (robot description, URDF)
Before this commit: robot milk, 1 links, 0 joints
Links:
- link base_link: mass 5 -> 0
