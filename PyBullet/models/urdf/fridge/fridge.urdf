Commit message: Completed goal5 cubes to box dataset

File: PyBullet/models/urdf/fridge/fridge.urdf (robot description, URDF)
Before this commit: robot walls, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=models/meshes/fridge/fridge.obj scale=10 10 10
