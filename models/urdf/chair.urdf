Commit message: Minor bug fixes

File: models/urdf/chair.urdf (robot description, URDF)
Before this commit: robot chair, 1 links, 0 joints
Links:
- link base_link: mass 35 -> 0.1
